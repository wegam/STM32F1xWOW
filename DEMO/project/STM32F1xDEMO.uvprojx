# Keil uVision project STM32F1xDEMO.uvprojx, settings and files
target DEMO (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: DEMO
  c include: ..\include;..\..\FWLIB\Lib_CM3\STM32F10x_StdPeriph_Driver\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Lib_Std;..\..\FWLIB\Lib_USB\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Protocol;..\..\FWLIB\TOOLS;..\..\Examples\APP_CM3;..\..\Examples\APP_HC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ../source/: DEMO.C main.c STM32_IT.c STM32_WOW.C
  group APP_CM3
    ../../Examples/APP_CM3/: A3987_TEST.C ADC_Temperature.C ADC_TEST.C Buzzer_TEST.C CAN_TEST.C CD4511BM_TEST.C font.c FX2N_14MR.C LK3U_40MR.C MX25L4006E.C OFFLINE_ISP.C OLED096_TEST.C PWM_LED.C PWM_TEST.C R2A15908SP.C SPI_TEST.C SPItoUSART.C STM32_LCD.C STM32F103C8T6.C TEST.C TM1618_TEST.C USART_TEST.C USBTEST_RS485TOUSART.C USBtoSPI.C VirtualCom.C
  group APP_HC
    ../../Examples/APP_HC/: MS0800_PC004V10.C MS0800_PL001V20.C MS0800_PM001V20.C PC001V21.C PC001V22.C PC004V21.C PC006V20.C PD002V30.C PD003V11.C PD003VG.C PD004V10.C PD006V20.C PD008V11.C PD011V10.C PD014V14.C PD014V15.C PL001V20.C PL006V10.C PL010V13.C PL013V10.C PM001V20.C PM004V10.C
  group Lib_WOW
    ../../FWLIB/Lib_WOW/SCR/: STM32_096OLED.C STM32_A3987.C STM32_ADC.C STM32_CAN.C STM32_CRC.C STM32_DAC.C STM32_DMA.C STM32_EXTI.C STM32_GPIO.C STM32_I2C.C STM32_NVIC.C STM32_PWM.C STM32_RCC.C STM32_RTC.C STM32_SDCard.C STM32_SPI.C STM32_SPI_Struct.C STM32_SYS.C STM32_SYSLED.C STM32_SYSTICK.C STM32_TIM.C STM32_TOOLS.C STM32_USART.C STM32_WDG.C
  group Lib_CM3
    ../../FWLIB/Lib_CM3/STM32F10x_StdPeriph_Driver/SCR/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Lib_USB
    ../../FWLIB/Lib_USB/SCR/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Components
    ../../FWLIB/Components/SCR/: 74HC165.C 74HC595.C A3987.C CD4511.C CS5530.c DRV8801.C EC11Encoder.C GT32L32M0180.C MOTOR.C R61509V.c SSD1963.C SWITCHID.C TM1618.C
  group Protocol
    ../../FWLIB/Protocol/: SPI_FLASH.C USART_ISP.C
  group TOOLS
    ../../FWLIB/TOOLS/: LinkedList.C
  group Startup/STM32F10x
    ../../FWLIB/Startup/STM32F10x/: cortexm3_macro.s stm32f10x_vector.s
  group Audio_Speaker
    ../../Examples/APP_USB/Audio_Speaker/source/: Audio_Speaker.c hw_config.c i2s_codec.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Custom_HID
    ../../Examples/APP_USB/Custom_HID/source/: Custom_HID.c hw_config.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Device_Firmware_Upgrade
    ../../Examples/APP_USB/Device_Firmware_Upgrade/source/: Device_Firmware_Upgrade.c hw_config.c spi_flash.c stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c dfu_mal.c flash_if.c fsmc_nor.c nor_if.c spi_if.c
  group JoyStickMouse
    ../../Examples/APP_USB/JoyStickMouse/source/: JoyStickMouse.c hw_config.c stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group Virtual_COM_Port
    ../../Examples/APP_USB/Virtual_COM_Port/source/: Virtual_COM_Port.c hw_config.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Document
    ../../FWLIB/Document/: C语言printf()输出格式大全.txt note.txt readme.txt USB说明.txt 常用C语言标准库函数.txt
target STM32F103C8T6 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: STM32F103C8T6
  c include: ..\include;..\..\FWLIB\Lib_CM3\STM32F10x_StdPeriph_Driver\INC;..\..\FWLIB\Lib_CM4\STM32F4xx_StdPeriph_Driver\inc;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Startup\STM32F4xx\Include;..\..\FWLIB\Lib_Std;..\..\FWLIB\Lib_USB\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Protocol;..\..\FWLIB\TOOLS;..\..\Examples\APP_CM3;..\..\Examples\APP_CM4;..\..\Examples\APP_HC;..\..\FWLIB\Components\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Audio_Speaker (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Audio_Speaker +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: Audio_Speaker
  c include: ..\include;..\..\FWLIB\Lib_CM3\STM32F10x_StdPeriph_Driver\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Lib_Std;..\..\FWLIB\Lib_USB\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Protocol;..\..\FWLIB\TOOLS;..\..\Examples\APP_CM3;..\..\Examples\APP_HC;..\..\Examples\APP_USB\Audio_Speaker\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Custom_HID (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Custom_HID +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: Custom_HID
  c include: ..\include;..\..\FWLIB\Lib_CM3\STM32F10x_StdPeriph_Driver\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Lib_Std;..\..\FWLIB\Lib_USB\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Protocol;..\..\FWLIB\TOOLS;..\..\Examples\APP_CM3;..\..\Examples\APP_HC;..\..\Examples\APP_USB\Custom_HID\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Device_Firmware_Upgrade (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Device_Firmware_Upgrade +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: Device_Firmware_Upgrade
  c include: ..\include;..\..\FWLIB\Lib_CM3\STM32F10x_StdPeriph_Driver\INC;..\..\FWLIB\Lib_USB\INC;..\..\Examples\APP_USB\Device_Firmware_Upgrade\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target JoyStickMouse (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: JoyStickMouse +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: JoyStickMouse
  c include: ..\include;..\..\FWLIB\Lib_CM3\STM32F10x_StdPeriph_Driver\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Lib_Std;..\..\FWLIB\Lib_USB\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Protocol;..\..\FWLIB\TOOLS;..\..\Examples\APP_CM3;..\..\Examples\APP_HC;..\..\Examples\APP_USB\JoyStickMouse\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Mass_Storage (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Mass_Storage +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: Mass_Storage
  c include: ..\include;..\..\FWLIB\Lib_CM3\STM32F10x_StdPeriph_Driver\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Lib_Std;..\..\FWLIB\Lib_USB\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Protocol;..\..\FWLIB\TOOLS;..\..\Examples\APP_CM3;..\..\Examples\APP_HC;..\..\Examples\APP_USB\Mass_Storage\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Virtual_COM_Port (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Virtual_COM_Port +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: Virtual_COM_Port
  c include: ..\include;..\..\FWLIB\Lib_CM3\STM32F10x_StdPeriph_Driver\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Lib_Std;..\..\FWLIB\Lib_USB\INC;..\..\FWLIB\Lib_WOW\INC;..\..\FWLIB\Protocol;..\..\FWLIB\TOOLS;..\..\Examples\APP_CM3;..\..\Examples\APP_HC;..\..\Examples\APP_USB\Virtual_COM_Port\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target R2A15908SP (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: R2A15908SP +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: R2A15908SP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target USART_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USART_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SSD1963 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SSD1963
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32_LCD (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: STM32_LCD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ADC_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: ADC_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ADC_Temperature (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: ADC_Temperature
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target CAN_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: CAN_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SPI_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SPI_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target OFFLINE_ISP (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: OFFLINE_ISP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target CD4511BM_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: CD4511BM_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PL001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PL001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PC004V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PC004V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MS0800_PM001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MS0800_PM001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target MX25L4006E (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: MX25L4006E
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target TM1618 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: TM1618
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target VirtualCom (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: VirtualCom
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target USBtoSPI (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USBtoSPI
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SPItoUSART (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: SPItoUSART
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PWM_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PWM_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target OLED096_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: OLED096_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target LK3U_40MR (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: LK3U_40MR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target FX2N_14MR (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: FX2N_14MR
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target A3987_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: A3987_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Buzzer_TEST (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: Buzzer_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PM001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PM001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC001V21 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC001V21
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD002V30 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD002V30
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL001V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL001V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC006V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC006V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL006V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL006V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD008V11 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD008V11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD011V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD011V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target PD006V20 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD006V20
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD004V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD004V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL010V13 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL010V13
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PL013V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PL013V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC004V21 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC004V21
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD003V11 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD003V11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD003VG (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD003VG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD014V14 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD014V14
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PD014V15 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PD014V15
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PM004V10 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PM004V10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target USBTEST_RS485TOUSART (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USBTEST_RS485TOUSART
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PC001V22 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PC001V22
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target PWM_LED (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: DEMO +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: PWM_LED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.0.0
